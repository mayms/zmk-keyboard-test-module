## boards/shields/test/Kconfig.defconfig
```kconfig
if SHIELD_TEST

config ZMK_KEYBOARD_NAME
    default "zmkkbtest"

config ZMK_BLE_EXPERIMENTAL_CONN
    default n

endif
```
